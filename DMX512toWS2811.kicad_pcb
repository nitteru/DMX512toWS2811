# Repository nitteru/DMX512toWS2811

## KiCad design DMX512toWS2811.kicad_pcb

Parts:
C1, C2, C3, C5, C7, C8, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Manufacturer_Part_Number GRM188F11H104ZA01
C4, C9: 10u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; Manufacturer_Part_Number GRM31CB31H106KA12
C6: 4700p; C_Disc_D12.5mm_W5.0mm_P10.00mm; Manufacturer_Part_Number DE1E3RA472MA4BH01F
C21: 1000p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
CA1, CA5: 330u; CP_Radial_D10.0mm_P5.00mm; Manufacturer_Part_Number 35PZJ330M10X9
CA2: 100u; CP_Radial_D6.3mm_P2.50mm; Manufacturer_Part_Number 16SEPC100M
CA3: 22u; CP_Radial_D6.3mm_P2.50mm; Manufacturer_Part_Number 35SEPF22M
CA4: 1000u; CP_Radial_D10.0mm_P5.00mm; Manufacturer_Part_Number 16SEPF1000M
CN1, CN4, CN5, CN6, CN7: TB112-2-2-E-1; TB11222E1; Manufacturer_Part_Number TB112-2-2-E-1
CN2: 18742; Manufacturer_Part_Number 18742
CN3: B6B-PH-K-S_LF__SN_; SHDR6W50P0X200_1X6_1390X450X600P; Manufacturer_Part_Number B6B-PH-K-S(LF)(SN)
D1, D2: D5V0L2B3SO-7; SOT96P240X100-3N; Manufacturer_Part_Number D5V0L2B3SO-7; Mouser Part Number 621-D5V0L2B3SO-7
D3: 1SS355VM; D_SOD-323F; Manufacturer_Part_Number 1SS355VM
D4, D5, D7: SMBJ5.0CA; DIONM5436X261N; Manufacturer_Part_Number SMBJ5.0CA; Mouser Part Number 576-SMBJ5.0CA
D6, D8: SBR2U30P1-7; SODFL3718X100N; Manufacturer_Part_Number SBR2U30P1-7; Mouser Part Number 621-SBR2U30P1-7
F1, F2, F4, F7: FUC-03A; FUC03A; Manufacturer_Part_Number FUC-03A
F3, F5, F6: NANOSMDC010F-2; FUSC3216X100N; Manufacturer_Part_Number NANOSMDC010F-2; Mouser Part Number 650-NANOSMDC010F-2
FL1, FL2: DLW21SN261SQ2L; DLW21SN121HQ2L; Manufacturer_Part_Number DLW21SN261SQ2L; Mouser Part Number 81-DLW21SN261SQ2L
FL3: BNX022-01B; BNX02201K; Manufacturer_Part_Number BNX022-01B; Mouser Part Number 81-BNX022-01B
IC1, IC2, IC7: MAX485ESA+; SOIC127P600X175-8N; Manufacturer_Part_Number MAX485ESA+; Mouser Part Number 700-MAX485ESA
IC3: TLP2361_TPL,E; 11-4L1S_5-PIN-SOIC_; Manufacturer_Part_Number TLP2361(TPL,E; Mouser Part Number 757-TLP2361(TPLE
IC4: TCK106AF,LF; SMV_1; Manufacturer_Part_Number TCK106AF,LF; Mouser Part Number 757-TCK106AFLF
IC5: PIC18F27Q43-I_SO; SOIC127P1030X265-28N; Manufacturer_Part_Number PIC18F27Q43-I/SO; Mouser Part Number 579-PIC18F27Q43-I/SO
IC6: HD74LV541AT-E; SOP65P640X110-20N; Manufacturer_Part_Number HD74LV541AT-E
IC8: NJU77551F-TE1; SOT95P280X130-5N; Manufacturer_Part_Number NJU77551F-TE1
J1, J2, J3: 7810-8P8C; 78108P8C; Manufacturer_Part_Number 7810-8P8C
L1: DFE322512F-100M=P2; 1277ASH100MP2; Manufacturer_Part_Number DFE322512F-100M=P2; Mouser Part Number 81-DFE322512F-100MP2
LED1, LED3, LED5: SML-E12M8WT86; LEDC1608X46N; Manufacturer_Part_Number SML-E12M8WT86; Mouser Part Number 755-SML-E12M8WT86
LED2, LED4: SML-E12U8WT86; LEDC1608X46N; Manufacturer_Part_Number SML-E12U8WT86; Mouser Part Number 755-SML-E12U8WT86
LED6: OSTBABS4C2B; Manufacturer_Part_Number OSTBABS4C2B
LED7: SML-E12U8WT86; LEDM168X46N; Manufacturer_Part_Number SML-E12U8WT86; Mouser Part Number 755-SML-E12U8WT86
PS1: MAU102; MAU109; Manufacturer_Part_Number MAU102
PS2: NID35-5; NID355; Manufacturer_Part_Number NID35-5; Mouser Part Number 709-NID35-5
Q1, Q3: TJ60S04M3L; Manufacturer_Part_Number TJ60S04M3L; Mouser Part Number N/A
Q2: 2SK1062_F_; SSM3K7002CFULF; Manufacturer_Part_Number 2SK1062(F)
R1, R2, R3, R4, R34: 100; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder; Manufacturer_Part_Number RG3216P-1000-B-T5
R5, R6, R15, R16, R17, R18, R21, R29, R30, R32, R33: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Manufacturer_Part_Number RC0603J10K
R7, R20, R35, R37: 100; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Manufacturer_Part_Number RC0603J100R
R8: 470k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Manufacturer_Part_Number RC0603J470K
R9, R11: 150k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Manufacturer_Part_Number RC0603J150K
R10: 240; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; Manufacturer_Part_Number RC0603J240R
R12: 300; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Manufacturer_Part_Number RC0603J300R
R13, R14, R19, R22, R23, R24, R25, R26, R27, R28, R31: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Manufacturer_Part_Number RC0603J1K
R36, R38, R39, R40: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Manufacturer_Part_Number RC0603J100K
R41, R42: 2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R44: 0; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R45, R46: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
S1: TS-06104; TS06104; Manufacturer_Part_Number TS-06104
S2: SS12D00G3; Manufacturer_Part_Number SS12D00G3
TP1, TP2, TP3: TestPoint; TestPoint_THTPad_D1.5mm_Drill0.7mm
VA1: ERZV07D220; Manufacturer_Part_Number ERZV07D220
X1: CXO_DIP8; Oscillator_DIP-8; Manufacturer_Part_Number KHO-HC1-TS-16.0000M

Connections:
5VOUT_EN: IC5.23 (RB2), R35.1
485_DE: IC5.15 (RC4), IC7.3 (DE), R33.1
485_nRE: IC5.14 (RC3), IC7.2 (~RE), R32.2
+5V: C5.2, C10.1, C11.2, C13.2, C17.2, C18.2, C19.2, C20.2, CA3.1, CA4.1, CN3.2, D3.1 (K), D6.1 (K), IC3.6 (VCC), IC4.5 (VIN), IC5.20 (VDD), IC6.20 (VCC), IC7.8 (VCC), IC8.5 (V+), PS2.1 (+VOUT_1), PS2.2 (+VOUT_2), PS2.3 (+VOUT_3), PS2.4 (+VOUT_4), Q1.3 (S), R14.1, R15.1, R16.1, R18.1, R19.2, R21.1, R30.1, R32.1, R36.1, X1.8 (Vcc)
+5V_ISO: C1.2, C2.2, C3.1, C4.1, IC1.8 (VCC), IC2.8 (VCC), PS1.6 (+VOUT), R6.1, R10.2, R12.1, R13.2
+BATT: CN1.1, CN2.1, F1.1, F1.2
-BATT: CN1.2, CN2.2, FL3.3 (PSG), VA1.2
/5V_OUT: CN4.2, D6.2 (A), Q1.2 (D)
/D+_OUT: CN6.2, F6.2
/D-_OUT: CN5.1, F5.2
/DATA+(A): J1.2, J2.2, R2.2
/DATA-(B): J1.1, J2.1, R1.1
/OSRAM_SIG_OUT: CN7.2, R41.2, R42.2
/WS_SIG_OUT: CN4.1, F3.2
BAT_VOL: C14.1, IC5.2 (RA0), R8.2, R9.1, R11.1
DMXPORTOUT_EN: IC5.7 (RA5), R37.1
GND: C5.1, C6.2, C7.2, C8.2, C9.2, C10.2, C11.1, C12.2, C13.1, C14.2, C15.2, C16.2, C17.1, C18.1, C19.1, C20.1, CA1.2, CA2.2, CA3.2, CA4.2, CA5.2, CN3.3, CN6.1, CN7.1, D4.1, D5.1, D7.1, FL3.4 (CG_1), FL3.5 (CG_2), FL3.6 (CG_3), IC3.4 (GND), IC4.2 (GND), IC5.8 (VSS_1), IC5.19 (VSS_2), IC6.10 (GND), IC7.5 (GND), IC8.2 (V-), LED3.1, LED4.1, LED5.1, LED6.4 (K_BL), LED6.5 (K_GL), LED6.6 (K_RL), LED7.1, PS1.2 (-VIN), PS2.5 (COM_1), PS2.6 (COM_2), Q2.2 (S), R9.2, R11.2, R17.1, R29.2, R33.2, R38.2, R44.1, S1.C1 (NO_1), S1.D1 (NO_2), S2.2 (COM), X1.4 (GND)
GND_ISO: C1.1, C2.1, C3.2, C4.2, C6.1, D1.3, D2.3, IC1.5 (GND), IC2.5 (GND), J1.3, J1.6, J1.9, J1.10, J2.3, J2.6, J2.9, J2.10, J3.3, J3.6, J3.9, J3.10, LED1.1, PS1.4 (-VOUT), R5.1, R10.1
ICSPCLK: CN3.5, IC5.27 (RB6/ICSPCLK)
ICSPDAT: CN3.4, IC5.28 (RB7/ICSPDAT)
ISOPS_EN: IC4.3 (CONTROL), IC5.5 (RA3), R17.2
unnamed: D1.1, FL1.1, R2.1
unnamed: D1.2, FL1.4, R1.2
unnamed: D2.1, FL2.1, R4.1
unnamed: D2.2, FL2.4, R3.2
unnamed: C12.1, D3.2 (A), R18.2, R20.1
unnamed: D4.2, F3.1, R34.2
unnamed: D8.2 (A), F4.1, F4.2, Q3.2 (D)
unnamed: F2.1, F2.2, FL3.1 (B), VA1.1
unnamed: FL1.2, IC1.6 (A)
unnamed: FL1.3, IC1.7 (B)
unnamed: IC1.2 (~RE), IC1.3 (DE), R5.2
unnamed: IC1.1 (RO), IC3.3 (CATHODE), R7.1
unnamed: FL2.2, IC2.6 (A)
unnamed: FL2.3, IC2.7 (B)
unnamed: IC2.2 (~RE), IC2.3 (DE), R6.2
unnamed: IC2.4 (DI), R7.2
unnamed: IC3.1 (ANODE), R12.2
unnamed: IC4.1 (VOUT), L1.2
unnamed: IC5.9 (RA7), X1.5 (OUT)
unnamed: IC5.24 (RB3), TP1.1
unnamed: IC5.25 (RB4), TP2.1
unnamed: IC5.26 (RB5), TP3.1
unnamed: IC6.11 (Y8), IC6.12 (Y7), IC6.13 (Y6), IC6.14 (Y5), IC6.15 (Y4), IC6.16 (Y3), IC6.17 (Y2), IC6.18 (Y1), IC6.19 (~OE2), R34.1
unnamed: D7.2, F6.1, IC7.6 (A)
unnamed: D5.2, F5.1, IC7.7 (B)
unnamed: IC8.1 (+INPUT), R44.2, R45.2, R46.2
unnamed: C21.2, IC8.3 (-INPUT), R42.1
unnamed: C21.1, IC8.4 (OUTPUT), R41.1
unnamed: J3.1, R3.1
unnamed: J3.2, R4.2
unnamed: LED1.2, R13.1
unnamed: LED2.2, R14.2
unnamed: LED3.2, R19.1
unnamed: LED4.2, R24.2
unnamed: LED5.2, R25.1
unnamed: LED6.1 (A_BL), R26.2
unnamed: LED6.2 (A_GL), R27.2
unnamed: LED6.3 (A_RL), R28.2
unnamed: LED7.2, R31.2
unnamed: C7.1, C9.1, CA2.1, L1.1, PS1.1 (+VIN)
unnamed: Q1.1 (G), R35.2, R36.2
unnamed: Q2.3 (D), R39.2
unnamed: Q2.1 (G), R37.2, R38.1
unnamed: Q3.1 (G), R39.1, R40.1
unnamed: R16.2, R22.1, S1.A1 (COM_1), S1.B1 (COM_2)
unnamed: R21.2, R23.1, S2.3 (NO)
OSIG_N: IC5.22 (RB1), R45.1
OSIG_P: IC5.21 (RB0), R46.1
PSMODE_SW: C16.1, IC5.10 (RA6), R23.2
PWM_B: IC5.13 (RC2), R26.1
PWM_G: IC5.12 (RC1), R27.1
PWM_R: IC5.11 (RC0), R28.1
PWR_LED: IC5.3 (RA1), R24.1
RESET: CN3.1, IC5.1 (~MCLR/VPP/RE3), R20.2
RST_SW: C15.1, IC5.6 (RA4), R22.2
SIGOUT: IC5.17 (RC6), IC6.2 (A1), IC6.3 (A2), IC6.4 (A3), IC6.5 (A4), IC6.6 (A5), IC6.7 (A6), IC6.8 (A7), IC6.9 (A8), R29.1
SIGOUT_nEN: IC5.18 (RC7), IC6.1 (~OE1), R30.2
SIG_STS: IC5.4 (RA2), R25.2
UART_RX: IC3.5 (VO_(OUTPUT)), IC5.16 (RC5), IC7.4 (DI), LED2.1, R15.2, R31.1
VDC: C8.1, CA1.1, CA5.1, D8.1 (K), FL3.2 (CB), PS2.7 (+VIN_1), PS2.8 (+VIN_2), Q3.3 (S), R8.1, R40.2
VPP: CN5.2, F7.1, F7.2

Notes on the sheet:
GND
DATA+
DATA-
CLCかI2Cの出力につなぐ
VPP
24V時: 3.3V

Board: 2 copper layers, 140.0 x 110.0 mm, 127 parts (0 on the bottom side), 82 nets.

## Commit log

2023-10-14 * DMX512受信とWS2811送信分の追加
2023-10-16 * バッテリー監視追加
2023-10-16 * 動作モード切り替えスイッチの追加
2023-10-16 * 外部電源供給回路にSWを追加 * MOSFETに逆流時の寄生ダイオード保護のためのダイオードを追加したほうがいいかも * リセットSW､モード切り替えSWを修正
2023-10-27 * 大まかに配線完了
2023-11-06 * アートワーク作業中
2023-11-06 * GNDパターン引き直し
2023-12-31 * ローカル保存分と同期
